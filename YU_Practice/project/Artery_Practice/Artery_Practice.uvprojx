# Keil uVision project Artery_Practice.uvprojx, settings and files
target Practice (6230000::V6.23::ARMCLANG)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Artery_Practice +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER
  c include: ..\..\Board_All\at_surf_f437_board;..\..\Board_All\at32f435_437_board;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\..\libraries\cmsis\dsp\ComputeLibrary\Include;..\..\libraries\cmsis\dsp\include;..\..\libraries\cmsis\dsp\PrivateInclude;..\..\libraries\drivers\inc;..\..\middlewares\i2c_application_library;..\inc
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main_buzzer.c main_gpio_poll.c main_gpio_int.c main_timer_led.c main_systick.c main_timer_int_led.c main_tmr_pwm_led.c main_tmr_pwm_scale_sound.c main_usart_prinf.c
  group board_bsp
    ../../Board_All/at_surf_f437_board/: at_surf_f437_board_buzz.c at_surf_f437_board_delay.c at_surf_f437_board_font.c at_surf_f437_board_key.c at_surf_f437_board_lcd.c at_surf_f437_board_pca9555.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
    ../../middlewares/i2c_application_library/: i2c_application.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group AT_SURF_MAIN
    ../../Board_All/at_surf_f437/examples/audio/src/: audio_main.c
    ../../Board_All/at_surf_f437/examples/buzz/src/: buzz_main.c
    ../../Board_All/at_surf_f437/examples/calendar/src/: calendar_main.c
    ../../Board_All/at_surf_f437/examples/camera/src/: camera_main.c
    ../../Board_All/at_surf_f437/examples/can/src/: can_main.c
    ../../Board_All/at_surf_f437/examples/dac/src/: dac_main.c
    ../../Board_All/at_surf_f437/examples/eeprom/src/: eeprom_main.c
    ../../Board_All/at_surf_f437/examples/infrared_receiver/src/: infrared_recieve_main.c
    ../../Board_All/at_surf_f437/examples/joystick/src/: joystick_main.c
    ../../Board_All/at_surf_f437/examples/key/src/: key_main.c
    ../../Board_All/at_surf_f437/examples/low_power_mode/src/: low_power_main.c
    ../../Board_All/at_surf_f437/examples/otg/src/: otg_main.c
    ../../Board_All/at_surf_f437/examples/picture/src/: picture_main.c
    ../../Board_All/at_surf_f437/examples/pwm_dac/src/: pwm_dac_main.c
    ../../Board_All/at_surf_f437/examples/qspi_flash/src/: qspi_flash_main.c
    ../../Board_All/at_surf_f437/examples/qspi_sram/src/: qspi_sram_main.c
    ../../Board_All/at_surf_f437/examples/rgb_led/src/: rgb_led_main.c
    ../../Board_All/at_surf_f437/examples/rs485/src/: rs485_main.c
    ../../Board_All/at_surf_f437/examples/sd_card/src/: sdcard_main.c
    ../../Board_All/at_surf_f437/examples/sdram/src/: sdram_main.c
    ../../Board_All/at_surf_f437/examples/tcp_server/src/: tcp_server_main.c
    ../../Board_All/at_surf_f437/examples/tft_lcd/src/: tft_lcd_main.c
    ../../Board_All/at_surf_f437/examples/touch/src/: touch_main.c
    ../../Board_All/at_surf_f437/examples/usart_printf/src/: usart_printf_main.c
    ../../Board_All/at_surf_f437/examples/variable_resistor/src/: var_resistor_main.c
    ../../Board_All/at_surf_f437/examples/video/src/: video_main.c
